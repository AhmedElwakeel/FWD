# Keil uVision project FWDProjectNo1.uvprojx, settings and files
target COTS (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FWDProjectNo1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\CTOS\COMMON;..\CTOS\MCAL\DET;..\CTOS\MCAL\DIO;..\CTOS\MCAL\GPT;..\CTOS\MCAL\Port;..\CTOS\MCAL\Interrupt;..\CTOS\HAL\Button;..\CTOS\HAL\LED
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group COMMON
    ../CTOS/COMMON/: Common_Macros.h Platform_Types.h tm4c123gh6pm_registers.h
  group MCAL
    ../CTOS/MCAL/DIO/: Dio.c Dio_PBcfg.c
    ../CTOS/MCAL/Port/: Port.c
    ../CTOS/MCAL/GPT/: Gpt.c
    ../CTOS/MCAL/Interrupt/: interrupt.c
  group HAL
    ../CTOS/HAL/Button/: Button.c
    ../CTOS/HAL/LED/: Led.c
  group APPLICATION
    ../CTOS/APPLICATION/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
