# Keil uVision project Static Arch.uvprojx, settings and files
target CTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Static Arch
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CTOS\MCAL\Includes;.\CTOS\HAL\Includes;.\CTOS\Service\Includes
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./CTOS/Application/: main.c
  group Service
    ./CTOS/Service/: Comm.c
  group HAL
    ./CTOS/HAL/: Buzzer.c Door.c Lights.c Speed.c Switch.c
  group MCAL
    ./CTOS/MCAL/: CAN.c DIO.c ICU.c Timer.c
  group FreeRTOS
    ./CTOS/FreeRTOS/: portASM.c tasks.c list.c queue.c port.c heap_2.c
